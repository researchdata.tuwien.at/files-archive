Properties of the parts of a building model (IFC4X3_ADD2)

# File
Description: ViewDefinition [Alignment-basedReferenceView]
File name: bachelorarbeit.ifc
Time: 2024-02-07T10:16:10
Author: redacted
Organization: redacted
Written by: redacted
Made in: redacted
Authorization: redacted

# IfcProject, Stationing
Description: Default Project Description

# IfcAlignment: Railway track alignment, Track alignment
In: Default Railway Name
PredefinedType: USERDEFINED

# IfcAlignmentCant, C1
RailHeadDistance: 1.435 m

# IfcCourse: BinderCourse, Binder
In: Default Railway Name
PredefinedType: USERDEFINED
PSet_Sweep - SweepStart: 0 m; SweepEnd: 340 m

# IfcSignal, Route Indicator_01
In: Default Railway Name
PredefinedType: VISUAL
